# Keil uVision project Demo.uvprojx, settings and files
target APP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Ports;.\uCOS-II;.\User;.\CMSIS_M3;..\Common\Drivers\include;..\Common\BoardSupport;..\Common\CoreSupport;..\Common\DeviceSupport;.\BSP;.\Code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS_M3/: startup_LPC177x_8x.s
  group CMSIS_M3
    ./CMSIS_M3/: core_cm3.c system_LPC177x_8x.c
  group Drivers
    ../Common/Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_systick.c lpc177x_8x_gpio.c
  group Ports
    ./Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-II
    ./uCOS-II/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_time.c ucos_ii.c ucos_ii.h os_cfg.h os_dbg_r.c os_tmr.c os_task.c
  group User
    ./User/: main.c bms.c display.c meter.c charger.c fram.c card.c ethernet.c link .c welink.c norflash.c
  group Code
    ./Code/: calculator.c print.c
  group BSP
    ./BSP/: gpio.c adc.c uart.c can.c ssp.c rtc.c timer.c pwm.c wdt.c
software components: CMSIS:CORE 5.0.1
